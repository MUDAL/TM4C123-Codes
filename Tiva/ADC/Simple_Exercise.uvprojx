# Keil uVision project Simple_Exercise.uvprojx, settings and files
target tm4c123gh6pm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Simple_Exercise
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.4.178\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group
    ./: main.c
    C:/ti/TivaWare_C_Series-2.1.4.178/examples/project/: startup_rvmdk.S
    C:/ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c uartstdio.h ustdlib.c ustdlib.h
  group TivaWare
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
