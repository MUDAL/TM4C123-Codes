# Keil uVision project BLANK.uvprojx, settings and files
target tm4c123 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BLANK
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USB HID
    ./: main.c
software components: CMSIS Driver:USB Device:Custom 2.2.0, CMSIS Driver:USB Host:Custom 2.2.0, CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, USB:CORE 6.12.8, USB:Device 6.12.8, USB:Device:HID 6.12.8, Device:Startup 1.0.1
